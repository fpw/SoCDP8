# Pass DTB identifier to module
KERNEL_BOOTARGS_zynq += "uio_pdrv_genirq.of_id=generic-uio"
